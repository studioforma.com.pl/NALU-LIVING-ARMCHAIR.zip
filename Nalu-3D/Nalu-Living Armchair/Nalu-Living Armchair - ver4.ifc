Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Nalu-Living Armchair - ver4.ifc
Time: 2024-10-24T10:14:49
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Nalu-Living Armchair_0 - ObjectType: SketchupGroup
 | Nalu-Living Armchair_1 - ObjectType: SketchupGroup
 | Nalu-Living Armchair_2 - ObjectType: SketchupGroup
 | Nalu-Living Armchair_3 - ObjectType: SketchupGroup
